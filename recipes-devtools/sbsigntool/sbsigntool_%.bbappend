SRC_URI_remove = "git://kernel.ubuntu.com/jk/sbsigntool"
SRC_URI = "git://github.com/osresearch/sbsigntools.git;branch=master"

SRCREV = "370abb7c49ec2a600f64fcbd441d9297124a5cb7"
